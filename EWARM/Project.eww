<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Learn STM Code.ewp</path>
  </project>
  <batchBuild />
</workspace>
